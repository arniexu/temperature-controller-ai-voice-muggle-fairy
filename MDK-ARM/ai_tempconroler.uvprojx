# Keil uVision project ai_tempconroler.uvprojx, settings and files
target ai_tempconroler (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ai_tempconroler +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,CMSIS_RTOS_V2
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../LIBJPEG/App;../LIBJPEG/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/Components/ili9341;../Drivers/BSP/Components/xpt2046;../Drivers/BSP/Components/Common;../UI/Core/Inc;../UI/LVGL;../Utilities/Fonts;../Utilities/Log;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/LibJPEG/include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/lvgl/src;../Middlewares/Third_Party/lvgl
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c hil_telemetry.c fsmc.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c usart.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sram.c sram_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/LIBJPEG/App
    ../LIBJPEG/App/: libjpeg.c
  group Application/User/LIBJPEG/Target
    ../LIBJPEG/Target/: jdata_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LibJPEG
    ../Middlewares/Third_Party/LibJPEG/source/: jcapimin.c jcapistd.c jdapimin.c jdapistd.c jcomapi.c jcparam.c jctrans.c jdtrans.c jcinit.c jcmaster.c jcmainct.c jcprepct.c jccoefct.c jccolor.c jcsample.c jcdctmgr.c jfdctint.c jfdctfst.c jfdctflt.c jchuff.c jcarith.c jcmarker.c jdatadst.c jdmaster.c jdinput.c jdmainct.c jdcoefct.c jdpostct.c jdmarker.c jdhuff.c jdarith.c jddctmgr.c jidctint.c jidctfst.c jidctflt.c jdsample.c jdcolor.c jdmerge.c jquant1.c jquant2.c jdatasrc.c jaricom.c jerror.c jmemmgr.c jutils.c jmemnobs.c
  group Drivers/BSP/ILI9341
    ../Drivers/BSP/Components/ili9341/: ili9341.c fsmc_8080.c
    ../Tests/BSP/: ili9341_self_test.c
  group Drivers/BSP/XPT2046
    ../Drivers/BSP/Components/xpt2046/: xpt2046.c
  group UI/Core
    ../UI/Core/Src/: display_drv.c bsp_stubs.c tianji_data.c tianji_dial.c tianji_particles.c tianji_ui.c tianji_voice.c touch_drv.c
    ../Tests/LVGL/: lvgl_mini_test.c
  group Utilities/Fonts
    ../Utilities/Fonts/: font8.c font12.c font16.c font20.c font24.c
  group Middlewares/LVGL/core
    ../Middlewares/Third_Party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/LVGL/draw
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Middlewares/LVGL/draw/sw
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group Middlewares/LVGL/extra
    ../Middlewares/Third_Party/lvgl/src/extra/: lv_extra.c
  group Middlewares/LVGL/extra/layouts/flex
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/flex/: lv_flex.c
  group Middlewares/LVGL/extra/layouts/grid
    ../Middlewares/Third_Party/lvgl/src/extra/layouts/grid/: lv_grid.c
  group Middlewares/LVGL/extra/libs/bmp
    ../Middlewares/Third_Party/lvgl/src/extra/libs/bmp/: lv_bmp.c
  group Middlewares/LVGL/extra/libs/ffmpeg
    ../Middlewares/Third_Party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
  group Middlewares/LVGL/extra/libs/freetype
    ../Middlewares/Third_Party/lvgl/src/extra/libs/freetype/: lv_freetype.c
  group Middlewares/LVGL/extra/libs/fsdrv
    ../Middlewares/Third_Party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group Middlewares/LVGL/extra/libs/gif
    ../Middlewares/Third_Party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group Middlewares/LVGL/extra/libs/png
    ../Middlewares/Third_Party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group Middlewares/LVGL/extra/libs/qrcode
    ../Middlewares/Third_Party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group Middlewares/LVGL/extra/libs/rlottie
    ../Middlewares/Third_Party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
  group Middlewares/LVGL/extra/libs/sjpg
    ../Middlewares/Third_Party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group Middlewares/LVGL/extra/libs/tiny_ttf
    ../Middlewares/Third_Party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
  group Middlewares/LVGL/extra/others/fragment
    ../Middlewares/Third_Party/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group Middlewares/LVGL/extra/others/gridnav
    ../Middlewares/Third_Party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
  group Middlewares/LVGL/extra/others/ime
    ../Middlewares/Third_Party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
  group Middlewares/LVGL/extra/others/imgfont
    ../Middlewares/Third_Party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
  group Middlewares/LVGL/extra/others/monkey
    ../Middlewares/Third_Party/lvgl/src/extra/others/monkey/: lv_monkey.c
  group Middlewares/LVGL/extra/others/msg
    ../Middlewares/Third_Party/lvgl/src/extra/others/msg/: lv_msg.c
  group Middlewares/LVGL/extra/others/snapshot
    ../Middlewares/Third_Party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group Middlewares/LVGL/extra/themes/basic
    ../Middlewares/Third_Party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
  group Middlewares/LVGL/extra/themes/default
    ../Middlewares/Third_Party/lvgl/src/extra/themes/default/: lv_theme_default.c
  group Middlewares/LVGL/extra/themes/mono
    ../Middlewares/Third_Party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
  group Middlewares/LVGL/extra/widgets/animimg
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
  group Middlewares/LVGL/extra/widgets/calendar
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group Middlewares/LVGL/extra/widgets/chart
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/chart/: lv_chart.c
  group Middlewares/LVGL/extra/widgets/colorwheel
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group Middlewares/LVGL/extra/widgets/imgbtn
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group Middlewares/LVGL/extra/widgets/keyboard
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
  group Middlewares/LVGL/extra/widgets/led
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/led/: lv_led.c
  group Middlewares/LVGL/extra/widgets/list
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/list/: lv_list.c
  group Middlewares/LVGL/extra/widgets/menu
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/menu/: lv_menu.c
  group Middlewares/LVGL/extra/widgets/meter
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/meter/: lv_meter.c
  group Middlewares/LVGL/extra/widgets/msgbox
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
  group Middlewares/LVGL/extra/widgets/span
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/span/: lv_span.c
  group Middlewares/LVGL/extra/widgets/spinbox
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
  group Middlewares/LVGL/extra/widgets/spinner
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
  group Middlewares/LVGL/extra/widgets/tabview
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group Middlewares/LVGL/extra/widgets/tileview
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
  group Middlewares/LVGL/extra/widgets/win
    ../Middlewares/Third_Party/lvgl/src/extra/widgets/win/: lv_win.c
  group Middlewares/LVGL/font
    ../Middlewares/Third_Party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group Middlewares/LVGL/hal
    ../Middlewares/Third_Party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/misc
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/widgets
    ../Middlewares/Third_Party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
software components: CMSIS:CORE 6.1.1
